# IAR project Hard_Fault_Sample.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NM1230 series Nuvoton NM1230 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\Device\Nuvoton\NM1230\Include; ..\..\..\Library\StdDriver\Inc; ..\..\..\Library\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Hard_Fault_Sample.bin
  ILINK.IlinkOutputFile: Hard_Fault_Sample.out
  ILINK.IlinkIcfFile: Hard_Fault_Sample.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NM1230/Source/IAR/: startup_NM1230.s
    ../../../Library/Device/Nuvoton/NM1230/Source/: system_NM1230.c
  group Libraries
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c usci_uart.c
  group User
    ../: main.c
