# Keil uVision project Hard_Fault_Sample.uvproj, settings and files
target Hard_Fault_Sample (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NM1234D Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: Hard_Fault_Sample
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NM1230\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_NM1230.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NM1230/Source/: system_NM1230.c
    ../../../Library/Device/Nuvoton/NM1230/Source/ARM/: startup_NM1230.s
  group User
    ../: main.c
  group Libraries
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c usci_uart.c
