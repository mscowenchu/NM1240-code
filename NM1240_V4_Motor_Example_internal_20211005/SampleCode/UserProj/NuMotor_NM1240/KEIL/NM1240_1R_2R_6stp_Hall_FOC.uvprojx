# Keil uVision project NM1240_1R_2R_6stp_Hall_FOC.uvprojx, settings and files
target NM1230_1R_2R_6stp_Hall_FOC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NM1244D48 Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.12
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: NM1240_1R_2R_6stp_Hall_FOC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NM1240\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NM1240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NM1240/Source/: system_NM1240.c
    ../../../../Library/Device/Nuvoton/NM1240/Source/ARM/: startup_NM1240.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c usci_uart.c gpio.c adc.c fmc.c
  group User
    ./program/: main.c INT_ISR.C motor_FOC.c motor_funtions.c motor_six_step.c PI_control.c protocol.c system_initialize.C variable_initialize.c svpwm.c
software components: CMSIS:CORE 5.1.2
